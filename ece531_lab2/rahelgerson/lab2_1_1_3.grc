options:
  parameters:
    author: gnuradio
    generate_options: qt_gui
    id: lab2_1_1_3
    output_language: python
    title: lab2_1_1_3
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '6000000000'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: uri
  id: variable
  parameters:
    value: '''usb:2.2.5'''
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: iio_attr_source_0
  id: iio_attr_source
  parameters:
    attr_type: '0'
    device: cf-ad9361-dds-core-lpc
    output: 'False'
    required_enable: 'False'
    samples_per_update: '1024'
    type: '1'
    update_interval_ms: '1'
    uri: usb
  states: {state: disabled}
- name: iio_device_sink_0
  id: iio_device_sink
  parameters:
    buffer_size: '32768'
    channels: '[''voltge0'', ''voltage1'']'
    cyclic: 'False'
    device: cf-ad9361-dds-core-lpc
    device_phy: ad9361-phy
    interpolation: '1'
    params: '[]'
    uri: 'local:'
  states: {state: disabled}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '[''voltge0'', ''voltage1'']'
    decimation: '1'
    device: '''cf-ad9361-dds-core-lpc'''
    device_phy: '''ad9361-phy'''
    params: '[]'
    uri: uri
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: fc
    samplerate: fs
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '2400000000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2084000'
  states: {state: disabled}
- name: iio_pluto_source_1
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: 50e6
    bbdc: 'True'
    buffer_size: 32768*2
    frequency: fc
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: fs
  states: {state: disabled}
- name: iio_pluto_source_2
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '2400000000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2084000'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0, '0']
- [analog_sig_source_x_1, '0', iio_pluto_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_short_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_short_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_short_0, '0', iio_device_sink_0, '0']
- [blocks_float_to_short_0_0, '0', iio_device_sink_0, '1']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [iio_attr_source_0, '0', qtgui_number_sink_0, '0']
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
