options:
  parameters:
    author: gnuradio
    generate_options: qt_gui
    id: lab2_1_1_3_0
    output_language: python
    title: lab2_1_1_3_0
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: '6000000000'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: uri
  id: variable
  parameters:
    value: '''usb:2.2.5'''
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: fs
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '[''voltge0'', ''voltage1'']'
    decimation: '1'
    device: '''cf-ad9361-dds-core-lpc'''
    device_phy: '''ad9361-phy'''
    params: '[]'
    uri: uri
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    frequency: fc
    samplerate: fs
    uri: uri
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: fs
    type: complex
  states: {}

connections:
- [analog_sig_source_x_1, '0', iio_pluto_sink_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_float_to_complex_0, '1']
- [iio_device_source_0, '0', blocks_short_to_float_0, '0']
- [iio_device_source_0, '1', blocks_short_to_float_0_0, '0']

metadata:
  file_format: 1
