options:
  parameters:
    author: gnuradio
    generate_options: qt_gui
    id: attribute_updater_blocks
    output_language: python
    title: attribute_updater_blocks
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: iio_attr_sink_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage1
    device: ad9361-phy
    output: 'True'
    required_enable: 'False'
    uri: 'local:'
  states: {}
- name: iio_attr_sink_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage0
    device: ad9361-phy
    output: 'True'
    required_enable: 'False'
    uri: 'local:'
  states: {}
- name: iio_attr_sink_0_0_0
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage0
    device: ad9361-phy
    output: 'True'
    required_enable: 'False'
    uri: 'local:'
  states: {}
- name: iio_attr_sink_0_1
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: altvoltage1
    device: ad9361-phy
    output: 'True'
    required_enable: 'False'
    uri: 'local:'
  states: {}
- name: iio_attr_updater_0
  id: iio_attr_updater
  parameters:
    attr: frequency
    update_interval_ms: '100'
    value: '915000000'
  states: {}
- name: iio_attr_updater_0_0
  id: iio_attr_updater
  parameters:
    attr: samplig_frequency
    update_interval_ms: '100'
    value: '2084000'
  states: {}
- name: iio_device_source_0
  id: iio_device_source
  parameters:
    buffer_size: '32768'
    channels: '[]'
    decimation: '1'
    params: '[]'
    uri: 'local:'
  states: {}

connections:
- [iio_attr_updater_0, out, iio_attr_sink_0, attr]
- [iio_attr_updater_0, out, iio_attr_sink_0_0, attr]
- [iio_attr_updater_0_0, out, iio_attr_sink_0_0_0, attr]
- [iio_attr_updater_0_0, out, iio_attr_sink_0_1, attr]

metadata:
  file_format: 1
