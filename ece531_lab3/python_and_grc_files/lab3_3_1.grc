options:
  parameters:
    author: gnuradio
    generate_options: qt_gui
    id: lab3_3_1
    output_language: python
    title: lab3_3_1
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '20'
    step: '5'
    stop: '100'
    value: '50'
  states: {}
- name: rx_LO
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 1e6
    step: '1000'
    stop: 6e9
    value: 314.95e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/gnuradio/Desktop/Loveliests_Stuff/ece531_lab3/samplesOut
    type: complex
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: rx_LO
    freq_span: 1e6
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: 5e6
    bbdc: 'True'
    buffer_size: '32768'
    frequency: rx_LO-120000
    gain1: '''slow_attack'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: 1e6
  states: {}

connections:
- [iio_pluto_source_0, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
