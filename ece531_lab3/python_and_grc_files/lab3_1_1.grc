options:
  parameters:
    generate_options: qt_gui
    id: lab3_1_1
    output_language: python
    title: lab3_1_1
  states: {}

blocks:
- name: ATSCT
  id: variable
  parameters:
    value: 54e6 + 1e6
  states: {}
- name: carondolet
  id: variable
  parameters:
    value: 463.85000e6
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 1e6
    step: '1000'
    stop: 200e6
    value: 70e6
  states: {}
- name: fs
  id: variable
  parameters:
    value: 6e9
  states: {}
- name: gandalf
  id: variable
  parameters:
    value: 150e6
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: freq
    freq_span: fs
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '52000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: freq
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '2084000'
  states: {}

connections:
- [iio_pluto_source_0, '0', fosphor_qt_sink_c_0, '0']

metadata:
  file_format: 1
