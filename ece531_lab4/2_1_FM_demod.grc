options:
  parameters:
    author: rahel gerson
    generate_options: qt_gui
    id: ece531_lab4_2
    output_language: python
    title: ece531_lab4_2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.304*1*10**6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '700e-3'
    step: '.5'
    stop: '2'
    value: '700e-3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '16'
    audio_pass: '15000'
    audio_stop: '16000'
    chan_rate: 384e3
    deviation: '75000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: volume control
    const: volume
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: 99.5e6
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    uri: 'usb:'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 48e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: FM_signal
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: FM_signal_demod
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
